# Keil uVision project teststandproject.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: template_project
  c flags: Optim=1 uC99=1
  c define: PART_TM4C1294NCPDT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ./: startup_rvmdk.S
    ./src/: main.c debug.c network_driver.c packet_receiver.c telemetry.c transducer.c networking.c thermocouple.c
  group TivaWare driverlib
    ./driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h onewire.c onewire.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group HW includes
    ./inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_onewire.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c1294ncpdt.h
  group uIP Library
    ./uip/: clock.h clock-arch.h lc.h lc-addrlabels.h lc-switch.h psock.c psock.h pt.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uip-conf.h uip-fw.c uip-fw.h uiplib.c uiplib.h uip-neighbor.c uip-neighbor.h uipopt.h uip-split.c uip-split.h
